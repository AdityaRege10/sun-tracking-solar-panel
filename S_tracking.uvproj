# Keil uVision project S_tracking.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: S_tracking +hex
  AfterMake: C:\Yash_E_drive\ideation\Solar_panel_tracking_shus\EXE\hex2bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;..\..\LCD_lib\LCD_lib\N76E003-master_lib\lcd-lib
  group Source Group 1
    ./: STARTUP.A51 s_tracking.c
    ./Common/: Common.c Delay.c PUTCHAR.C
    ../../LCD_lib/LCD_lib/N76E003-master_lib/lcd-lib/: lcd.c
